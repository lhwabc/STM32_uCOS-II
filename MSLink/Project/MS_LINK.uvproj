# Keil uVision project MS_LINK.uvproj, settings and files
target MSLink (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MSLink +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_LD
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\USER;..\USER\APP;..\USER\BSP;..\USER\uCOS-II\Ports;..\USER\uCOS-II\Source;..\Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_ld.s
  group App
    ../USER/APP/: app.c
    ./: stm32f10x_it.c
  group FWlib
    ../Libraries/FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group BSP
    ../USER/BSP/: BSP.c led.c key.c
  group uCOS-II\Ports
    ../USER/uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II\Source
    ../USER/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
