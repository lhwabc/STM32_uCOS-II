# Keil uVision project MS-LINK.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MS-LINK +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_LD, USE_STDPERIPH_DRIVER
  c include: ..\USER\App;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER\BSP\ICP;..\USER\BSP\KEY;..\USER\BSP\LED;..\USER\BSP\STMFLASH;..\USER\BSP\Programings;..\USER\uCOS-II\PORT;..\USER\uCOS-II\Source;..\USER\USB\MS_USB_HID\inc;..\USER\USB\STM32_USB-FS-Device_Driver\inc;..\Project;..\SYSTEM\FWlib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./: startup_stm32f10x_ld.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group App
    ../USER/App/: App.c
    ../SYSTEM/CMSIS/: system_stm32f10x.c
    ../SYSTEM/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group MS_USB_HID
    ../USER/USB/MS_USB_HID/src/: hw_config.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group STM32_USB-FS-Device_Driver
    ../USER/USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
