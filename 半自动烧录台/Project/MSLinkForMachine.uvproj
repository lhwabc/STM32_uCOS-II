# Keil uVision project MSLinkForMachine.uvproj, settings and files
target MSLinkForMachine (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MSLinkForMachine +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Project;..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\USER\APP;..\USER\BSP;..\USER\uCOS-II\Ports;..\USER\uCOS-II\Source;..\USER\USB\MS_USB_HID\inc;..\USER\USB\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group setup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group App
    ../USER/APP/: app.c
    ./: stm32f10x_it.c
  group BSP
    ../USER/BSP/: BSP.c ICP.c OLP.c Signal.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c
  group uCOS-II\Ports
    ../USER/uCOS-II/Ports/: os_dbg.c os_cpu_c.c os_cpu_a.asm
  group uCOS-II\Source
    ../USER/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group USB\MS_USB_HID
    ../USER/USB/MS_USB_HID/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB\STM32_USB-FS-Device_Driver
    ../USER/USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
